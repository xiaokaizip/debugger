# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: HL +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\delay;..\tft;..\GUI;..\HARDWARE\xpt2046;..\HARDWARE\spi;C:\Keil_v5\C51\INC\STC
  group main
    ./: main.c
  group delay
    ../delay/: delay.c
  group tft
    ../tft/: tft.C
  group gui
    ../GUI/: GUI.C
  group HARDWARE
    ../HARDWARE/xpt2046/: xpt2046.c
    ../HARDWARE/spi/: spi.c
